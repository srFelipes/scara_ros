Commit message: Add files via upload
Ahora el SCARa está pegado al piso

File: src/nelen/urdf/nelen.urdf (robot description, URDF)
Before this commit: robot nelen, 4 links, 3 joints
Links:
- added link world
Joints:
- added joint suelo: type fixed, parent world, child base_link
